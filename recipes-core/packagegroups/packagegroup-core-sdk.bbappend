# Our current toolchain is not including the gcc sanitizer libraries
SANITIZERS:tcmode-external-sourcery = ""
