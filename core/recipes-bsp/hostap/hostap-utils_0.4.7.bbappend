FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://ldflags.patch"
