LTTNGMODULES_arm = "lttng-modules"
