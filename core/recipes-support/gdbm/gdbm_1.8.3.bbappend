FILESEXTRAPATHS_prepend := "${THISDIR}/gdbm:"
SRC_URI += "file://ldflags.patch"
