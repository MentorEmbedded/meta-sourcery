inherit external-nopseudo
