FILES_${PN} += "${prefix}/license"
FILES_MIRRORS += "${prefix}/|${base_prefix}\n"
