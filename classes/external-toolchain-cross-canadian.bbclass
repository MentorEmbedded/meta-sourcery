inherit external-toolchain cross-canadian external-toolchain-wrap-bin 

EXTERNAL_CROSS_BINARIES ?= ""
EXTERNAL_CROSS_NOPSEUDO = "gcc g++ cpp"


